# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F30X_HD,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS\GD\GD32F30x\Include;.\Libraries\CMSIS;.\Libraries\CMSIS\GD\GD32F30x\Source\ARM;.\Libraries\GD32F30x_standard_peripheral\GD32F30x_Lib\Head;.\Libraries\GD32F30x_standard_peripheral\GD32F30x_Lib\Inc;.\CODE\APP;.\CODE\Driver;.\CODE\Algorithm;.\CODE\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: main.c main.h systick.c systick.h gd32f30x_it.c Mydef.h
  group startup
    ./Libraries/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ./Libraries/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Libraries
    ./Libraries/GD32F30x_standard_peripheral/GD32F30x_Lib/Src/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
    ./Libraries/GD32F30x_standard_peripheral/GD32F30x_Lib/Inc/: gd32f30x_adc.h gd32f30x_bkp.h gd32f30x_can.h gd32f30x_crc.h gd32f30x_ctc.h gd32f30x_dac.h gd32f30x_dbg.h gd32f30x_dma.h gd32f30x_enet.h gd32f30x_exmc.h gd32f30x_exti.h gd32f30x_fmc.h gd32f30x_fwdgt.h gd32f30x_gpio.h gd32f30x_i2c.h gd32f30x_misc.h gd32f30x_pmu.h gd32f30x_rcu.h gd32f30x_rtc.h gd32f30x_sdio.h gd32f30x_spi.h gd32f30x_timer.h gd32f30x_usart.h gd32f30x_wwdgt.h
  group CODE/APP
    ./CODE/APP/: Control.c Control.h FOC.c FOC.h PID.c PID.h TimerTask.c TimerTask.h VOFA.c VOFA.h
  group CODE/Driver
    ./CODE/Driver/: AS5047P.c AS5047P.h DRV8323.c DRV8323.h WS2812B.c WS2812B.h
  group CODE/BSP
    ./CODE/BSP/: ADC.c ADC.h Flash.c Flash.h GPIO.c GPIO.h PWM.c PWM.h Serial.c Serial.h SPI.c SPI.h Timer.c Timer.h CAN.c CAN.h
  group CODE/Algorithm
    ./CODE/Algorithm/: filter.c filter.h math_util.c math_util.h
